# Keil uVision project Project.uvprojx, settings and files
target BDLABKHAND (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: BDLABKHAND +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL,STM32F10X_HD,Simorgh50N,WVGA
  c include: .\..\Config;.\..\User;.\..\..\bsp_lib;.\..\Simorgh;.\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\..\..\Utilities\STM32_EVAL;.\..\..\Utilities\STM32_EVAL\Common;.\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;.\..\..\Utilities\Third_Party\fat_fs\inc;.\..\..\Libraries\STemWinLibrary522\inc;.\..\..\Libraries\STemWinLibrary522\Config;..\..\Libraries\CMSIS\Include
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8005800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Appli
    ../Simorgh/: Config.c
    ./../User/: bsp.c main.c system_stm32f10x.c
    ../User/: startup_stm32f10x_hd_mdkarm.s app_cfg.h includes.h stm32xxx_it.c sys.h
  group STemWin_V522
    ../../Libraries/STemWinLibrary522/Lib/: STemWin522_CM3_Keil.lib
    ../../Libraries/STemWinLibrary522/OS/: GUI_X.c
    ../Config/: LCDConf_stm3210e_eval.c GUIConf_stm3210e_eval.c ili9225g.c
    ../../Libraries/STemWinLibrary522/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Libraries
    ./../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_fsmc_sram.c stm3210e_eval_lcd.c
    ./../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp_lib
    ../../bsp_lib/BEEP/: beep.c
    ../../bsp_lib/FATFS/: ff.c diskio.c
    ../../bsp_lib/GPS/: gps.c
    ../../bsp_lib/GSM/: gsm.c
    ../../bsp_lib/KEY/: Keypad.c
    ../../bsp_lib/RTC/: rtc.c
    ../../bsp_lib/SD/: MMC_SD.C
    ../../bsp_lib/SRAM/: sram.c
    ../../bsp_lib/USART/: usart.c
    ../../bsp_lib/crc/: crc16.c crc7.c
    ../../bsp_lib/TOUCH/: touch.c
    ../../bsp_lib/NRF24L01/: 24l01.c
    ../../bsp_lib/SPI/: spi.c
    ../../bsp_lib/FLASH/: flash.c
    ../../bsp_lib/WDG/: wdg.c
    ../../bsp_lib/eiaes/: eiaes.c
    ../../bsp_lib/MFRC/: iso14443ab.c mfrc531.c
    ../../bsp_lib/Voice/: Voice.c
    ../../bsp_lib/SmartCard/: smartcard.c
    ../../bsp_lib/pn532/: pn532.c
    ../../bsp_lib/ECARD/: ecard.c
    ../../bsp_lib/ESP8266/: ESP8266.c
  group Simorgh
    ../Simorgh/: menu3d.c Inputbox.c Font.c Firmware.c BusDoor.c Apark.c BusDoorWifi.c BusDoorWifi.h
  group PNG
    ../../Libraries/STemWinLibrary522/PNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c gzio.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pnggccrd.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngvcrd.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group Forms
    ../Simorgh/Forms/: ConfirmDlg.c futil.c GetNumberBox.c Kalas.c Sahmiye.c TransactionsList.c
  group RdLib
    ../../bsp_lib/RdLib/types/: RdLib.h
    ../../bsp_lib/RdLib/comps/phhalHw/src/: phhalHw.c
    ../../bsp_lib/RdLib/comps/phhalHw/src/Rc632/: phhalHw_Rc632.c phhalHw_Rc632_Int.c phhalHw_Rc632_Cmd.c
    ../../bsp_lib/RdLib/comps/phbalReg/src/: phbalReg.c
    ../../bsp_lib/RdLib/comps/phalMfc/src/: phalMfc.c phalMfc_Int.c
    ../../bsp_lib/RdLib/comps/phpalI14443p3a/src/: phpalI14443p3a.c
    ../../bsp_lib/RdLib/comps/phpalI14443p3b/src/: phpalI14443p3b.c
    ../../bsp_lib/RdLib/comps/phpalI14443p4/src/: phpalI14443p4.c
    ../../bsp_lib/RdLib/comps/phpalI14443p4a/src/: phpalI14443p4a.c
    ../../bsp_lib/RdLib/comps/phpalMifare/src/: phpalMifare.c
    ../../bsp_lib/RdLib/comps/phTools/src/: phTools.c
    ../../bsp_lib/RdLib/comps/phKeyStore/src/: phKeyStore.c
    ../../bsp_lib/RdLib/comps/phKeyStore/src/Rc632/: phKeyStore_Rc632.c
    ../../bsp_lib/RdLib/: RdLib.c
    ../../bsp_lib/RdLib/comps/phhalHw/src/Rc523/: phhalHw_Rc523.c phhalHw_Rc523_Cmd.c phhalHw_Rc523_Int.c
target Torgheh (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Torgheh +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL,STM32F10X_HD,Torgheh,
  c include: .\..\Config;.\..\User;.\..\..\bsp_lib;.\..\Simorgh;.\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;.\..\..\Utilities\STM32_EVAL;.\..\..\Utilities\STM32_EVAL\Common;.\..\..\Utilities\STM32_EVAL\STM3210E_EVAL;.\..\..\Utilities\Third_Party\fat_fs\inc;.\..\..\Libraries\STemWinLibrary522\inc;.\..\..\Libraries\STemWinLibrary522\Config
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8005800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target APARKLABKHAND (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: APARKLABKHAND +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL,STM32F10X_HD,Simorgh50N,WithWIFI
  c include: as above
  asm include: .\..\Config
  memory RVCT4: ROM 0x8005800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target BUSDOOR_WIFI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Hesam +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_STM3210E_EVAL,STM32F10X_HD,Simorgh50N,WVGA,WithWIFI
  c include: as above
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8005800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 6.1.1
